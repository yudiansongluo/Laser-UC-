# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: APM32F103C8 APEXMIC
  pack: APEXMIC.APM32F1xx_DFP.1.0.2
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\APP\led;.\Public;.\APP\beep;.\APP\smg;.\APP\key;.\APP\exti;.\APP\time;.\APP\pwm;.\APP\iwdg;.\APP\wwdg;.\APP\input;.\APP\touch_key;.\APP\wkup;.\APP\adc;.\APP\adc_temp;.\APP\dac;.\APP\pwm_dac;.\APP\dma;.\APP\rtc;.\APP\24Cxx;.\APP\iic;.\APP\ds18b20;.\APP\hwjs;.\APP\rs485;.\APP\can;.\APP\tftlcd;.\APP\hwjs;.\APP\hexify;.\APP\nrf24l01;.\APP\spi;.\APP\input;.\APP\gps;.\APP\function;.\APP\module;.\APP\voice;.\APP\voice_queue;.\APP\voice_inter;.\UCOSIII\uC-CPU;.\UCOSIII\uC-LIB;.\UCOSIII\uCOS-III;.\UCOSIII\uC-CPU;.\UCOSIII\uCOS_CONFIG;.\UCOSIII\uCOS-III\Source;.\UCOSIII\uC-LIB\Ports\ARM-Cortex-M3\RealView;.\UCOSIII\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;.\UCOSIII\uCOS_BSP;.\UCOSIII\uC-CPU\ARM-Cortex-M3\RealView
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c stm32f10x_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_wwdg.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_rtc.c stm32f10x_can.c stm32f10x_fsmc.c stm32f10x_spi.c
    ./Libraries/STM32F10x_StdPeriph_Driver/inc/: stm32f10x_spi.h
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group APP
    ./APP/led/: led.c
    ./APP/tftlcd/: tftlcd.c
    ./APP/hwjs/: hwjs.c hwjs.h
    ./APP/nrf24l01/: nrf24l01.c nrf24l01.h
    ./APP/spi/: spi.c spi.h
    ./APP/gps/: gps.c gps.h
    ./APP/module/: module.c module.h
    ./APP/function/: function.c function.h
    ./APP/time/: time.c time.h
    ./APP/voice/: voice.c voice.h
  group Public
    ./Public/: system.c SysTick.c usart.c
  group UCOSIII-BSP
    ./UCOSIII/uCOS_BSP/: bsp.c
  group UCOSIII_CPU
    ./UCOSIII/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm
    ./UCOSIII/uC-CPU/: cpu_core.c
  group UCOSIII_LIB
    ./UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ./UCOSIII/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group UCOSIII_CORE
    ./UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ./UCOSIII/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_c.c os_cpu.h os_cpu_a.s
  group UCOSIII_CONFIG
    ./UCOSIII/uCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
